<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LED_blink.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\try\try.ewp</path>
  </project>
  <batchBuild/>
</workspace>


