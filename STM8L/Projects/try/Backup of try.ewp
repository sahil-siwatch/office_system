# IAR project Backup of try.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver/inc
    ../../../../../STM8L-Discovery_dev/Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x_gpio.h
  group STM8L15x_StdPeriph_Driver/src
    ../../../../../STM8L-Discovery_dev/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_gpio.c
  group User/inc
    ../../../../../STM8L-Discovery_dev/Project/Project_template/inc/: stm8l15x_it.h
  group User/src
    ./: main.c
    ../../../../../STM8L-Discovery_dev/Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h
    ../../../../../STM8L-Discovery_dev/Project/Project_template/src/: stm8l15x_it.c
